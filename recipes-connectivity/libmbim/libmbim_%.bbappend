PV = "1.34.0"

SRCREV = "f628413fb7664dc89559218a1c805f741d3506d0"
SRC_URI = "git://gitlab.freedesktop.org/mobile-broadband/libmbim.git;protocol=https;branch=mbim-1-34"
