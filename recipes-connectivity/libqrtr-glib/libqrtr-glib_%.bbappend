PV = "1.4.0"

SRCREV = "01f323f26e6c6f72f455045566c8fa897e2509d0"
SRC_URI = "git://gitlab.freedesktop.org/mobile-broadband/libqrtr-glib.git;protocol=https;branch=qrtr-1-4"
