PV = "1.38.0"

SRCREV = "b36b53dce896536bd1b6fc99de0e40246375da45"
SRC_URI = "git://gitlab.freedesktop.org/mobile-broadband/libqmi.git;protocol=https;branch=qmi-1-38"
