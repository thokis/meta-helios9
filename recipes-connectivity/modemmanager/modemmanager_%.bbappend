PV = "1.24.2"

SRCREV = "f2b9ab1ad78d322f32134a444b5b54c6e8160e19"
SRC_URI = "git://gitlab.freedesktop.org/mobile-broadband/ModemManager.git;protocol=https;branch=mm-1-24"
